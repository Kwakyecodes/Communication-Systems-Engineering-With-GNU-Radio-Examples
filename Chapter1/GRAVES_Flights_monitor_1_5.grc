options:
  parameters:
    generate_options: qt_gui
    id: GRAVES_Flights_monitor_1_5
    output_language: python
    title: 'GRAVES RADAR Adalm-Pluto Receiver: Flights Monitor'
  states: {}

blocks:
- name: df
  id: variable_qtgui_range
  parameters:
    comment: Correct any internal thermal clock drift
    start: '-10e3'
    step: '1'
    stop: 10e3
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.536e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '300'
    gain: '1.0'
    samp_rate: samp_rate/100
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    comment: Fs -> 786 Hz
    decim: '20'
    samp_rate: samp_rate/100
    taps: taps
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(143050000)
    gain1: '''manual'''
    manual_gain1: '35'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Fs -> 76.8kHz
    cutoff_freq: samp_rate/40
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/40
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Fs -> 15.36kHz
    cutoff_freq: samp_rate/200
    decim: '5'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: samp_rate/1000
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/20/5/20
    comment: |-
      Freqeuncy spectrum is -384Hz to 384Hz
      Enough to monitor comercial flights
    fc: '0'
    fftsize: 1024*4
    int_max: '-60'
    int_min: '-120'
    type: complex
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
