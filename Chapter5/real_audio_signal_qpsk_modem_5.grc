options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: real_audio_signal_qpsk_modem_5
    output_language: python
    title: Transmitting and recovering real audio signal using QPSK
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0'
    step: '1'
    stop: '3'
    value: '0'
  states: {}
- name: my_const_qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts * sps, 1.0, 0.4, int(5 * sps * nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32767'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/32767
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/emmanuelkwakyenyantakyi/Desktop/sound.mp3
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const_qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: my_const_qpsk
    differential: 'True'
    excess_bw: '0.4'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0125664'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.707107'
    loop_bw: '0.00628318'
    max_dev: '1.5'
    nfilters: '16'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: Constellation Diagram
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_mod
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: to_process
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: to_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_mod
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: to_process
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: to_demod
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_char_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_short_0, '0', blocks_short_to_char_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_1_0, '0']
- [blocks_short_to_char_0, '0', virtual_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_short_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_2, '0']
- [digital_diff_decoder_bb_0, '0', blocks_delay_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_2, '0', analog_agc_xx_0, '0']
- [virtual_source_3, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
