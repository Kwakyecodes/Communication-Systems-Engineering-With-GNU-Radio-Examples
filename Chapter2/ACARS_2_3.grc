options:
  parameters:
    generate_options: qt_gui
    id: ACARS_2_3
    output_language: python
    title: Getting broadcasted messages from commercial flights
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    comment: Decimation Factor
    value: '10'
  states: {}
- name: my_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 72e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '5'
  states: {}
- name: acars_acars_0
  id: acars_acars
  parameters:
    filename: /tmp/log2
    saveall: 'False'
    threshold: '10'
  states: {state: disabled}
- name: acars_acars_0_0
  id: acars_acars
  parameters:
    filename: /tmp/log3
    saveall: 'False'
    threshold: '10'
  states: {state: disabled}
- name: acars_acars_1
  id: acars_acars
  parameters:
    filename: /tmp/log1
    saveall: 'False'
    threshold: threshold
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(N/2)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: (samp_rate * 6)/N/5
  states: {state: disabled}
- name: analog_am_demod_cf_1
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(N/2)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: (samp_rate * 6)/N/5
  states: {}
- name: analog_am_demod_cf_2
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(N/2)
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: (samp_rate * 6)/N/5
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 200e3
    comment: 131.525 MHz secondary frequency
    decim: N
    samp_rate: samp_rate
    taps: my_taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-125e3'
    comment: 131.850 MHz New Europe channel
    decim: N
    samp_rate: samp_rate
    taps: my_taps
    type: ccc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(131.725e6)
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: At 131.725 MHz primatery Europe frequency
    cutoff_freq: 72e3
    decim: N
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(N/2)
    interp: '6'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(N/2)
    interp: '6'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: int(N/2)
    interp: '6'
    type: ccc
  states: {state: disabled}

connections:
- [analog_am_demod_cf_0, '0', acars_acars_0_0, '0']
- [analog_am_demod_cf_1, '0', acars_acars_1, '0']
- [analog_am_demod_cf_2, '0', acars_acars_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_2, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_1, '0']
- [rational_resampler_xxx_1, '0', analog_am_demod_cf_2, '0']
- [rational_resampler_xxx_2, '0', analog_am_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
