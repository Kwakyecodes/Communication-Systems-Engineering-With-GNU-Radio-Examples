options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: FM_broadcast_2_4
    output_language: python
    title: 'Adalm-Pluto FM brodadcast: monitoring stations'
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '0.1'
    stop: '110'
    value: '91.4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(f * 1e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Center frequency = f*1e6
    fc: f * 1e6
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
