options:
  parameters:
    generate_options: qt_gui
    id: decoding_digital_RDS_channel_2_5
    output_language: python
    title: Decode the digital RDS channel identifying the radio frequency emitter
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '0.1'
    stop: '110'
    value: '97.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*32
  states: {}
- name: sps
  id: variable
  parameters:
    comment: |-
      1187.5 bits/second in Manchestor encoding
      = 1187.5*2 symbols/second sampled at samp_rate/8/16
    value: samp_rate/8/16/(1187.5 * 2)
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2.1e3
    gain: '1.0'
    samp_rate: samp_rate/8
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/8/4)
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 0.06/2
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '2'
    samp_rate: samp_rate/8
    taps: taps
    type: fcc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(f * 1e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 130e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '8'
    gain: '1'
    samp_rate: samp_rate/16
    type: fir_filter_ccf
    width: '250'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/8/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/8
    type: fir_filter_fff
    width: samp_rate/8/64
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: Effect of Costas loop
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: Clock recovery output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    name: Costas Output
    size: '1024'
    srate: samp_rate/16
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/8
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_abs_xx_0, '0']
- [digital_costas_loop_cc_0, '0', low_pass_filter_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_complex_to_arg_0, '0']
- [low_pass_filter_1, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_1_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
