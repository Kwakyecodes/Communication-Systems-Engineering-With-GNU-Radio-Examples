options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: fm_broadcast_audio_2_4
    output_language: python
    title: Listening to FM radio broadcast
  states: {}

blocks:
- name: Naudio
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Ndec
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Ntaps
  id: variable
  parameters:
    value: '80'
  states: {}
- name: f
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '0.1'
    stop: '110'
    value: '94.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: samp_rate = 48k * Ndec * Naudio
    value: 48e3 * Ndec * Naudio
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: Naudio
    comment: |-
      Input rate should be WBFM bandwidth
      or about 200kHz
    quad_rate: samp_rate/Ndec
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Sampling/Audio rate determined by sound card
    samp_rate: int(samp_rate/Ndec/Naudio)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(f * 1e6)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/Ndec/2
    decim: Ndec
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/Ntaps
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/Ndec/Naudio
    comment: Monitor frequency spectrum
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
