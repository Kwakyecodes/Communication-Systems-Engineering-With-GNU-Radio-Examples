options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: LR_stereo_fm_broadcast_2_4
    output_language: python
    title: Monitoring L+R, L-R and stereo of FM broadcast
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '88'
    step: '0.1'
    stop: '110'
    value: '95.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.536e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/8
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/8/4)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(f * 1e6)
    gain1: '''slow_attack'''
    manual_gain1: '45'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: usb:0.2.5
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2/8
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/64
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/8/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/8
    type: fir_filter_fff
    width: samp_rate/8/64
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f * 1e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/8
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
