options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: DABplus_receiver_7_4
    output_language: python
    title: gr-dab DAB+ receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: int(227.360e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.048e6)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_fic_decode_vc_0
  id: dab_fic_decode_vc
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: dab_ofdm_demod_cc_0
  id: dab_ofdm_demod_cc
  parameters:
    dab_mode: '1'
    samp_rate: samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2500000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: Constellation Diagram
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [dab_ofdm_demod_cc_0, '0', dab_fic_decode_vc_0, '0']
- [dab_ofdm_demod_cc_0, '1', blocks_vector_to_stream_0, '0']
- [iio_pluto_source_0, '0', dab_ofdm_demod_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
