options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: satellite_identification_using_gold_seq_4_2
    output_language: python
    title: Identify which satellite is broadasting gps signal using correlation with gold sequence...
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: samp_rate/1000
  states: {}
- name: df
  id: variable_qtgui_range
  parameters:
    comment: Manual doppler shift compensation
    start: '-7e3'
    step: '250'
    stop: 7e3
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_complex_to_mag_2
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_2_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Real GPS signal record
    file: /Users/emmanuelkwakyenyantakyi/Desktop/Documents/College/SDR_2026_27/GNU_SDR_Intro/Chapter4/GPS-L1-2022-03-27.sigmf-data
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: Gold code PRN31
    file: /Users/emmanuelkwakyenyantakyi/Desktop/Documents/College/SDR_2026_27/GNU_SDR_Intro/Chapter4/gps_L1_PRN31_4Msps.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    comment: Gold code PRN32
    file: /Users/emmanuelkwakyenyantakyi/Desktop/Documents/College/SDR_2026_27/GNU_SDR_Intro/Chapter4/gps_L1_PRN32_4Msps.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: int(N)
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: int(N)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(N)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(N)
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(N)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(N)
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(N)
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: int(N)
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: int(N)
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: int(N)
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: int(N)
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    fft_size: int(N)
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: df
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccf
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"xcorr prn31"'
    size: int(N)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"xcorr prn32"'
    size: int(N)
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_2, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_file_source_0_1, '0', blocks_stream_to_vector_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_2, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_0_2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_1_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_2, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_2_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_1_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_2, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_2_0, '0', blocks_vector_to_stream_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
