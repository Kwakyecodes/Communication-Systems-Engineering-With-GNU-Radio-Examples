options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: DABplus_start_of_frame_gen_6_4
    output_language: python
    title: DAB+ start of frame generation
  states: {}

blocks:
- name: dab_freq
  id: variable
  parameters:
    value: 227.360e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: Start
    name: Test
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: dab_ofdm_synchronization_cvc_0
  id: dab_ofdm_synchronization_cvc
  parameters:
    cyclic_prefix_length: '504'
    fft_length: '2048'
    null_symbol_length: '2656'
    symbols_per_frame: '76'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(dab_freq)
    gain1: '''manual'''
    manual_gain1: '45'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [dab_ofdm_synchronization_cvc_0, '0', blocks_tag_debug_0, '0']
- [dab_ofdm_synchronization_cvc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [iio_pluto_source_0, '0', dab_ofdm_synchronization_cvc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
