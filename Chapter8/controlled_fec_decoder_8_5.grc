options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: controlled_fec_decoder_8_5
    output_language: python
    title: Controlled FEC decoder
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/emmanuelkwakyenyantakyi/Desktop/Documents/College/SDR_2026_27/GNU_SDR_Intro/Chapter8/output.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/emmanuelkwakyenyantakyi/Desktop/Documents/College/SDR_2026_27/GNU_SDR_Intro/Chapter8/input.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '64'
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_0, '0', fec_extended_decoder_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_head_0, '0']
- [fec_extended_decoder_0, '0', blocks_unpacked_to_packed_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
