options:
  parameters:
    author: emmanuelkwakyenyantakyi
    generate_options: qt_gui
    id: store_clean_bits_from_raw_IQ_signal_8_5
    output_language: python
    title: Recover and store clean stream of bits (0s and 1s) from raw IQ signal
  states: {}

blocks:
- name: nfilts
  id: variable
  parameters:
    value: '8'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/sps, 0.35, int(11 * sps * nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 156.8e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/symb_rate
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 72e3
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '+1'
    lo: '-1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Size of this file is ~75 MB
      We've reduced the size by a factor of ~8.7!
    file: /Users/emmanuelkwakyenyantakyi/Desktop/meteor_softbits.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Size of this file is ~650 MB
    file: /Users/emmanuelkwakyenyantakyi/Desktop/MeteorM2N_180501_17h52_after_resampler.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_qpsk().base()
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*numpy.pi/500
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '0.707'
    loop_bw: 2*numpy.pi/2000
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '2.5'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: After carrier and timing synchronization
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', analog_agc2_xx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
